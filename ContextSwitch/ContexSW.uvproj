# Keil uVision project ContexSW.uvproj, settings and files
target Contex Switch SIM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ContexSW
  c flags: Optim=1
  c define: DEBUG_0
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./src/: startup_LPC17xx.s
  group System Code
    ./src/: uart_polling.c Retarget.c system_LPC17xx.c
  group Kernel Code
    ./src/: main_svc.c process.c HAL.c mmu.h mmu.c timer.c cmd.c debug_print.c uart_irq.c msg.c bit_vector.c queue.c system_processes.c
    ./src/p_queue/: p_queue.c
  group User Code
    ./src/: usr_proc.c
  group Documents
    ./: Abstract.txt
target Contex Switch RAM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: ContexSW
  c flags: Optim=1
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
